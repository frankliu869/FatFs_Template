# Keil uVision project practice.uvprojx, settings and files
target practice (6190000::V6.19::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: practice +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fsmc.c sdio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_spi.c stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_fsmc.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_sram.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group hardware
    ../../../STM32F1_BSP/src/: delay.c sys.c bsp_usart.c
    ../../../STM32F1_BSP/package/LCD-FSMC/: LCD_FSMC.c
    ../../../STM32F1_BSP/package/bsp_sdio_sdcard/: bsp_sdio_sd.c
    ../../../STM32F1_BSP/package/w25qxx/: bsp_flash_w25q.c
    ../../../STM32F1_BSP/package/bsp_malloc/: bsp_malloc.c
    ../../../STM32F1_BSP/package/bsp_sccb/: bsp_sccb.c
    ../../../STM32F1_BSP/package/bsp_ov7725/: bsp_ov7725.c
  group FatFs
    ../FatFS/ff14b/source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
software components: CMSIS:CORE 5.6.0
